Commit message: Updated urdf

File: mcap/1x_eve/models/eve_r3.urdf (robot description, URDF)
Before this commit: robot eve_r3, 24 links, 23 joints
Links:
- added link base_link
Joints:
- added joint j_base: type fixed, parent base_link, child pelvis
